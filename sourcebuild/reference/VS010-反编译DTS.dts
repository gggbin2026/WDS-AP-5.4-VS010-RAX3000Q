/ {
	soc_version_minor = <0x01000000>;
	soc_version_major = <0x01000000>;
	cpu_type = <0xf7010000>;
	flash_type = <0x0b000000>;
	tz_version = "CRM-TZ.WNS.4.0-00089
";
	boot_version = "CRM-BOOT.BF.3.3.1.1-00066
";
	machid = "";
	MP_256 = [];
	#address-cells = "";
	#size-cells = "";
	interrupt-parent = "";
	model = "CUCC VS010";
	compatible = "cucc,vs010", "qcom,ipq5018-ap-mp02.1", "qcom,ipq5018-mp02.1", "qcom,ipq5018";
	memory {
		device_type = "memory";
		reg = <0x00000000 0x40000000 0x00000000 0x10000000>;
	};
	reserved-memory {
		#address-cells = "";
		#size-cells = "";
		ranges = [];
		nss@40000000 {
			no-map = [];
			reg = <0x00000000 0x40000000 0x00000000 0x01000000>;
		};
		tzapp@4a400000 {
			no-map = [];
			phandle = "";
		};
		tzapp_data@4a700000 {
			compatible = "shared-dma-pool";
			no-map = [];
			phandle = "";
		};
		smem@4ab00000 {
			no-map = [];
			reg = <0x00000000 0x4ab00000 0x00000000 0x00100000>;
			phandle = "
";
		};
		tz@4ac00000 {
			no-map = [];
			reg = <0x00000000 0x4ac00000 0x00000000 0x00200000>;
		};
		bt@7000000 {
			no-map = [];
			reg = <0x00000000 0x07000000 0x00000000 0x00058000>;
			phandle = ",";
		};
		q6_mem_regions@4B000000 {
			no-map = [];
			reg = <0x00000000 0x4b000000 0x00000000 0x03400000>;
			phandle = "!";
		};
		q6_code_data@4B000000 {
			no-map = [];
			reg = <0x00000000 0x4b000000 0x00000000 0x00060000>;
		};
		q6_ipq5018_data@4C400000 {
			no-map = [];
			reg = <0x00000000 0x4c400000 0x00000000 0x00d00000>;
			phandle = "$";
		};
		m3_dump@4D100000 {
			no-map = [];
			reg = <0x00000000 0x4d100000 0x00000000 0x00100000>;
			phandle = "%";
		};
		q6_etr_dump@4D200000 {
			no-map = [];
			reg = <0x00000000 0x4d200000 0x00000000 0x00100000>;
			phandle = """;
		};
		q6_qcn6122_data1@4D300000 {
			no-map = [];
			reg = <0x00000000 0x4d300000 0x00000000 0x00f00000>;
			phandle = "&";
		};
		m3_dump_qcn6122_1@4E200000 {
			no-map = [];
			reg = <0x00000000 0x4e200000 0x00000000 0x00100000>;
			phandle = "'";
		};
		q6_qcn6122_etr_1@4E300000 {
			no-map = [];
			reg = <0x00000000 0x4e300000 0x00000000 0x00100000>;
			phandle = "(";
		};
	};
	clocks {
		sleep-clk {
			compatible = "fixed-clock";
			clock-frequency = <0x00007d00>;
			#clock-cells = "";
			phandle = "";
		};
		xo {
			compatible = "fixed-clock";
			clock-frequency = <0x016e3600>;
			#clock-cells = "";
			phandle = "";
		};
	};
	cpus {
		#address-cells = "";
		#size-cells = "";
		cpu@0 {
			device_type = <0x63707500>;
			compatible = "arm,cortex-a53";
			reg = "";
			enable-method = "psci";
			qcom,acc = "";
			next-level-cache = "";
			clocks = "", "";
			clock-names = <0x63707500>;
			operating-points = "a�", "��";
			clock-latency = "@";
			phandle = "D";
		};
		cpu@1 {
			device_type = <0x63707500>;
			compatible = "arm,cortex-a53";
			enable-method = "psci";
			reg = "";
			qcom,acc = "";
			next-level-cache = "";
			clocks = "", "";
			clock-names = <0x63707500>;
			operating-points = "a�", "��";
			clock-latency = "@";
			phandle = "F";
		};
		l2-cache {
			compatible = "cache";
			cache-level = "";
			phandle = "";
		};
	};
	pmu {
		compatible = "arm,cortex-a7-pmu";
		interrupts = "", "", "";
	};
	psci {
		compatible = "arm,psci-1.0";
		method = <0x736d6300>;
	};
	qseecom {
		compatible = "ipq5018-qseecom";
		memory-region = "", "";
	};
	firmware {
		qfprom {
			compatible = "qcom,qfprom-sec";
			img-addr = <0x4a800000>;
			img-size = <0x00400000>;
			fuse-blow-size-required = "";
		};
	};
	hwlock {
		compatible = "qcom,tcsr-mutex";
		syscon = "	", "�";
		#hwlock-cells = "";
		phandle = "";
	};
	smem {
		compatible = "qcom,smem";
		memory-region = "
";
		hwlocks = "";
	};
	qti,tzlog {
		compatible = "qti,tzlog";
		interrupts = "", "";
		qti,tz-diag-buf-size = <0x00002000>;
		qti,tz-ring-off = "";
		qti,tz-log-pos-info-off = "�";
	};
	srd_trace {
		compatible = <0x73726400>;
	};
	soc {
		#address-cells = "";
		#size-cells = "";
		ranges = "����";
		dma-ranges = [];
		compatible = "simple-bus";
		hs_m31phy@5b000 {
			compatible = "qca,m31-usb-hsphy";
			reg = "�", " ��", "";
			reg-names = "m31usb_phy_base", "qscratch_base";
			phy_type = "utmi";
			resets = "", "O";
			reset-names = "usb2_phy_reset";
			status = "ok";
			phandle = "";
		};
		ssuniphy@5d000 {
			compatible = "qca,ipq5018-uni-ssphy";
			reg = <0x0005d000 0x00000800>;
			clocks = "", "�", "", "�";
			clock-names = "pipe_clk", "phy_cfg_ahb_clk";
			resets = "", "c";
			reset-names = "por_rst";
			#phy-cells = "";
			status = "disabled";
		};
		mdio@88000 {
			#address-cells = "";
			#size-cells = "";
			compatible = "qcom,qca-mdio", "qcom,ipq40xx-mdio";
			reg = "�", "d";
			status = "ok";
			resets = "", "";
			reset-names = "gephy_mdc_rst";
			phandle = "";
			ethernet-phy@0 {
				reg = "";
			};
		};
		mdio@90000 {
			#address-cells = "";
			#size-cells = "";
			compatible = "qcom,qca-mdio";
			reg = "	", "d";
			status = "ok";
			pinctrl-0 = "";
			pinctrl-names = "default";
			phy-reset-gpio = "", "";
			phandle = "";
			ethernet-phy@0 {
				reg = "";
			};
		};
		qrng@e3000 {
			compatible = "qcom,msm-rng";
			reg = <0x000e3000 0x00001000>;
			clocks = "", "T";
			clock-names = "km_clk_src";
			qcom,no-qrng-config = [];
		};
		dma@704000 {
			compatible = "qcom,bam-v1.7.0";
			reg = <0x00704000 0x00020000>;
			interrupts = "�", "";
			clocks = "", ",";
			clock-names = "bam_clk";
			#dma-cells = "";
			qcom,ee = "";
			qcom,controlled-remotely = "";
			qti,config-pipe-trust-reg = "";
			phandle = "";
		};
		crypto@73a000 {
			compatible = "qcom,crypto-v5.1";
			reg = <0x0073a000 0x00006000>;
			clocks = "", ",", "", "-", "", ".";
			clock-names = "iface", "bus", "core";
			dmas = "", "", "", "";
			dma-names = "rx", "tx";
			qce,cmd_desc_support = [];
		};
		ess-instance {
			num_devices = "";
			ess-switch@0x39c00000 {
				compatible = "qcom,ess-switch-ipq50xx";
				reg = <0x39c00000 0x00200000>;
				switch_access_mode = "local bus";
				clocks = "", "(", "", ")", "", "�", "", "�", "", "G", "", "H", "", "7", "", ":", "", "<", "", "?", "", "5", "", "6", "", "�", "", "�", "", "9", "", ";", "", ">", "", "@", "", "n", "", "p", "", "8", "", "=";
				clock-names = "cmn_ahb_clk", "cmn_sys_clk", "uniphy_ahb_clk", "uniphy_sys_clk", "gcc_mdio0_ahb_clk", "gcc_mdio1_ahb_clk", "gcc_gmac0_cfg_clk", "gcc_gmac0_sys_clk", "gcc_gmac1_cfg_clk", "gcc_gmac1_sys_clk", "uniphy0_port1_rx_clk", "uniphy0_port1_tx_clk", "uniphy1_port5_rx_clk", "uniphy1_port5_tx_clk", "nss_port1_rx_clk", "nss_port1_tx_clk", "nss_port2_rx_clk", "nss_port2_tx_clk", "gcc_snoc_gmac0_ahb_clk", "gcc_snoc_gmac1_ahb_clk", "gcc_gmac0_ptp_clk", "gcc_gmac1_ptp_clk";
				resets = "", "", "", "]", "", "", "", "", "", "n", "", "o";
				reset-names = "gephy_bcr_rst", "uniphy_bcr_rst", "gmac0_bcr_rst", "gmac1_bcr_rst", "uniphy1_soft_rst", "gephy_misc_rst";
				switch_mac_mode = "";
				cmnblk_clk = "internal_96MHz";
				qcom,port_phyinfo {
					port@0 {
						port_id = "";
						phy_address = "";
						mdiobus = "";
					};
					port@1 {
						port_id = "";
						forced-speed = "�";
						forced-duplex = "";
					};
				};
				led_source@0 {
					source = "";
					mode = "normal";
					speed = <0x616c6c00>;
					blink_en = "enable";
					active = <0x6c6f7700>;
				};
			};
			ess-switch1@1 {
				device_id = "";
				compatible = "qcom,ess-switch-qca83xx";
				switch_access_mode = "mdio";
				mdio-bus = "";
				reset_gpio = "";
				switch_cpu_bmp = "@";
				switch_lan_bmp = "";
				switch_wan_bmp = "";
				qca,ar8327-initvals = "`", "", "", "�", "", "&�", "�", "
�E", "��Ad�", "|", "N", "�", "N";
				qcom,port_phyinfo {
					port@0 {
						port_id = "";
						phy_address = "";
					};
					port@1 {
						port_id = "";
						phy_address = "";
					};
					port@2 {
						port_id = "";
						phy_address = "";
					};
					port@3 {
						port_id = "";
						phy_address = "";
					};
				};
			};
		};
		ess-uniphy@98000 {
			compatible = "qcom,ess-uniphy";
			reg = <0x00098000 0x00000800>;
			uniphy_access_mode = "local bus";
			status = "disabled";
		};
		phy@7e000 {
			compatible = "qca,uni-pcie-phy-gen2";
			reg = <0x0007e000 0x00000800>;
			phy-type = "gen2";
			#phy-cells = "";
			clocks = "", "�";
			clock-names = "pipe_clk";
			resets = "", "/", "", "0";
			reset-names = "phy", "phy_phy";
			mode-fixed = "";
			status = "disabled";
			phandle = "";
		};
		phy@86000 {
			compatible = "qca,uni-pcie-phy-gen2";
			reg = <0x00086000 0x00001000>;
			phy-type = "gen2";
			#phy-cells = "";
			clocks = "", "�";
			clock-names = "pipe_clk";
			resets = "", "#", "", "$";
			reset-names = "phy", "phy_phy";
			mode-fixed = "";
			x2 = "";
			status = "disabled";
			phandle = "";
		};
		pinctrl@1000000 {
			compatible = "qcom,ipq5018-pinctrl";
			reg = <0x01000000 0x00300000>;
			interrupts = "�", "";
			gpio-controller = [];
			#gpio-cells = "";
			gpio-ranges = "", "/";
			interrupt-controller = [];
			#interrupt-cells = "";
			pinctrl-0 = "";
			pinctrl-names = "default";
			phandle = "";
			blsp0_uart_pins {
				phandle = "";
				blsp0_uart_rx {
					pins = "gpio28";
					function = "blsp0_uart1";
					drive-strength = "";
					input-enable = [];
					bias-disable = [];
					bias-pull-up = [];
				};
				blsp0_uart_tx {
					pins = "gpio29";
					function = "blsp0_uart1";
					drive-strength = "";
					bias-disable = [];
					output-high = [];
					bias-pull-up = [];
				};
			};
			blsp0_spi_pins {
				phandle = "";
				mux {
					pins = "gpio10", "gpio11", "gpio12", "gpio13";
					function = "blsp0_spi";
					drive-strength = "";
					bias-disable = [];
				};
			};
			qspi_nand_pins {
				phandle = "";
				qspi_clock {
					pins = "gpio9";
					function = "qspi_clk";
					drive-strength = "";
					bias-disable = [];
				};
				qspi_cs {
					pins = "gpio8";
					function = "qspi_cs";
					drive-strength = "";
					bias-disable = [];
				};
				qspi_data {
					pins = "gpio4", "gpio5", "gpio6", "gpio7";
					function = "qspi_data";
					drive-strength = "";
					bias-disable = [];
				};
			};
			mdio_pinmux {
				phandle = "";
				mux_0 {
					pins = "gpio36";
					function = <0x6d646300>;
					drive-strength = "";
					bias-pull-up = [];
				};
				mux_1 {
					pins = "gpio37";
					function = "mdio";
					drive-strength = "";
					bias-pull-up = [];
				};
				mux_2 {
					pins = "gpio26";
					function = "gpio";
					drive-strength = "";
					output-low = [];
				};
			};
			btss_pins {
				phandle = "";
				mux_0 {
					pins = "gpio4";
					function = "btss0";
					bias-pull-down = [];
				};
				mux_1 {
					pins = "gpio5";
					function = "btss1";
					bias-pull-down = [];
				};
				mux_2 {
					pins = "gpio6";
					function = "btss2";
					bias-pull-down = [];
				};
				mux_3 {
					pins = "gpio7";
					function = "btss3";
					bias-pull-down = [];
				};
			};
			button_pins {
				phandle = "O";
				wps_button {
					pins = "gpio34";
					function = "gpio";
					drive-strength = "";
					bias-pull-up = [];
				};
			};
			leds_pins {
				phandle = "P";
				mesh {
					pins = "gpio33";
					function = "gpio";
					drive-strength = "";
					bias-pull-down = [];
				};
				pwr {
					pins = "gpio31";
					function = "gpio";
					drive-strength = "";
					bias-pull-down = [];
				};
			};
		};
		syscon@1905000 {
			compatible = "syscon";
			reg = <0x01905000 0x00008000>;
			phandle = "	";
		};
		syscon@193d100 {
			compatible = "syscon";
			reg = "��", "";
			phandle = "";
		};
		gcc@1800000 {
			compatible = "qcom,gcc-ipq5018";
			reg = <0x01800000 0x00080000>;
			clocks = "", "";
			clock-names = "xo", "sleep_clk";
			#clock-cells = "";
			#reset-cells = "";
			phandle = "";
		};
		syscon@1945000 {
			compatible = "syscon";
			reg = <0x01945000 0x0000e000>;
			phandle = "";
		};
		scm {
			compatible = "qcom,scm";
			qcom,dload-mode = "";
		};
		sdhci@7804000 {
			compatible = "qcom,sdhci-msm-v5";
			reg = <0x07804000 0x00001000>;
			reg-names = "hc_mem";
			interrupts = "{", "", "�", "";
			interrupt-names = "hc_irq", "pwr_irq";
			clocks = "", "k", "", "l";
			clock-names = "iface", "core";
			mmc-ddr-1_8v = [];
			mmc-hs200-1_8v = [];
			max-frequency = <0x0b71b000>;
			bus-width = "";
			non-removable = [];
			status = "disabled";
		};
		dma@7884000 {
			compatible = "qcom,bam-v1.7.0";
			reg = <0x07884000 0x0001d000>;
			interrupts = "�", "";
			clocks = "", "";
			clock-names = "bam_clk";
			#dma-cells = "";
			qcom,ee = "";
			phandle = "";
		};
		spi@78b5000 {
			compatible = "qcom,spi-qup-v2.2.1";
			#address-cells = "";
			#size-cells = "";
			reg = <0x078b5000 0x00000600>;
			interrupts = "_", "";
			spi-max-frequency = [02faf080];
			clocks = "", "", "", "";
			clock-names = "core", "iface";
			dmas = "", "", "", "";
			dma-names = "tx", "rx";
			status = "ok";
			pinctrl-0 = "";
			pinctrl-names = "default";
			cs-select = "";
			m25p80@0 {
				#address-cells = "";
				#size-cells = "";
				reg = "";
				compatible = "n25q128a11";
				linux,modalias = "m25p80", "n25q128a11";
				spi-max-frequency = [02faf080];
				use-default-sizes = [];
			};
		};
		i2c@78b7000 {
			compatible = "qcom,i2c-qup-v2.2.1";
			#address-cells = "";
			#size-cells = "";
			reg = <0x078b7000 0x00000600>;
			interrupts = "a", "";
			clocks = "", "", "", "";
			clock-names = "iface", "core";
			clock-frequency = "�";
			dmas = "", "	", "", "";
			dma-names = "rx", "tx";
			status = "disabled";
		};
		dma@7984000 {
			compatible = "qcom,bam-v1.7.0";
			reg = <0x07984000 0x0001c000>;
			interrupts = "�", "";
			clocks = "", "g";
			clock-names = "bam_clk";
			#dma-cells = "";
			qcom,ee = "";
			status = "ok";
			phandle = "";
		};
		qpic-nand@79b0000 {
			qcom,training_offset = <0x00880000>;
			qcom,phase = "";
			qcom,iomacromax_clk = <0x1312d000>;
			compatible = "qcom,ebi2-nandc-bam-v2.1.1";
			reg = <0x079b0000 0x00010000>;
			#address-cells = "";
			#size-cells = "";
			clocks = "", "h", "", "g", "", "i";
			clock-names = "core", "aon", "io_macro";
			dmas = "", "", "", "", "", "", "";
			dma-names = "tx", "rx", "cmd", "sts";
			status = "ok";
			pinctrl-0 = "";
			pinctrl-names = "default";
			nandcs@0 {
				compatible = "qcom,nandcs";
				reg = "";
				#address-cells = "";
				#size-cells = "";
				nand-ecc-strength = "";
				nand-ecc-step-size = <0x00000200>;
				nand-bus-width = "";
				partition@0 {
					label = "0:SBL1";
					reg = <0x00000000 0x00080000>;
				};
				partition@80000 {
					label = "0:MIBIB";
					reg = <0x00080000 0x00080000>;
				};
				partition@100000 {
					label = "0:BOOTCONFIG";
					reg = <0x00100000 0x00040000>;
				};
				partition@140000 {
					label = "0:BOOTCONFIG1";
					reg = <0x00140000 0x00040000>;
				};
				partition@180000 {
					label = "0:QSEE";
					reg = <0x00180000 0x00100000>;
				};
				partition@280000 {
					label = "0:QSEE_1";
					reg = <0x00280000 0x00100000>;
				};
				partition@380000 {
					label = "0:DEVCFG";
					reg = <0x00380000 0x00040000>;
				};
				partition@3c0000 {
					label = "0:DEVCFG_1";
					reg = <0x003c0000 0x00040000>;
				};
				partition@400000 {
					label = "0:CDT";
					reg = <0x00400000 0x00040000>;
				};
				partition@440000 {
					label = "0:CDT_1";
					reg = <0x00440000 0x00040000>;
				};
				partition@480000 {
					label = "0:APPSBLENV";
					reg = <0x00480000 0x00080000>;
				};
				partition@500000 {
					label = "0:APPSBL";
					reg = <0x00500000 0x00140000>;
				};
				partition@640000 {
					label = "0:APPSBL_1";
					reg = <0x00640000 0x00140000>;
				};
				partition@780000 {
					label = "0:ART";
					reg = <0x00780000 0x00100000>;
				};
				partition@880000 {
					label = "0:TRAINING";
					reg = <0x00880000 0x00080000>;
				};
				partition@900000 {
					label = "rootfs";
					reg = <0x00900000 0x06e00000>;
				};
			};
		};
		nss-dp-common {
			compatible = "qcom,nss-dp-common";
			qcom,tcsr-base = <0x01937000>;
		};
		qcom,nss_crypto {
			compatible = "qcom,nss-crypto";
			#address-cells = "";
			#size-cells = "";
			qcom,max-contexts = "@";
			qcom,max-context-size = "�";
			ranges = [];
			ce5_node {
				compatible = "qcom,ce5";
				reg-names = "crypto_pbase", "bam_base";
				reg = <0x0073a000 0x00006000 0x00704000 0x00020000>;
				qcom,dma-mask = "";
				qcom,transform-enabled = [];
				qcom,aes128-cbc = [];
				qcom,aes256-cbc = [];
				qcom,aes128-ctr = [];
				qcom,aes256-ctr = [];
				qcom,aes128-ecb = [];
				qcom,aes256-ecb = [];
				qcom,3des-cbc = [];
				qcom,sha160-hash = [];
				qcom,sha256-hash = [];
				qcom,sha160-hmac = [];
				qcom,sha256-hmac = [];
				qcom,aes128-cbc-sha160-hmac = [];
				qcom,aes256-cbc-sha160-hmac = [];
				qcom,aes128-ctr-sha160-hmac = [];
				qcom,aes256-ctr-sha160-hmac = [];
				qcom,3des-cbc-sha160-hmac = [];
				qcom,3des-cbc-sha256-hmac = [];
				qcom,aes128-cbc-sha256-hmac = [];
				qcom,aes256-cbc-sha256-hmac = [];
				qcom,aes128-ctr-sha256-hmac = [];
				qcom,aes256-ctr-sha256-hmac = [];
				engine0 {
					qcom,ee = "", "";
				};
			};
		};
		serial@78b0000 {
			compatible = "qcom,msm-uartdm-v1.4", "qcom,msm-uartdm";
			reg = <0x078b0000 0x00000200>;
			interrupts = "l", "";
			clocks = "", """, "", "";
			clock-names = "core", "iface";
			status = "disabled";
		};
		serial@78af000 {
			compatible = "qcom,msm-uartdm-v1.4", "qcom,msm-uartdm";
			reg = <0x078af000 0x00000200>;
			interrupts = "k", "";
			clocks = "", "!", "", "";
			clock-names = "core", "iface";
			status = "ok";
		};
		usb3@8A00000 {
			compatible = "qcom,ipq5018-dwc3";
			#address-cells = "";
			#size-cells = "";
			ranges = [];
			reg = <0x08af8800 0x00000100 0x08a00000 0x0000e000>;
			reg-names = "qscratch_base", "dwc3_base";
			clocks = "", "{", "", "�", "", "�", "", "�", "", "�", "", "�", "", "�", "", "�";
			clock-names = "sys_noc_axi", "master", "sleep", "mock_utmi", "cfg_ahb_clk", "aux_clk", "lfps_clk", "pipe_clk";
			assigned-clocks = "", "{", "", "�", "", "�";
			assigned-clock-rates = "�tP�tP��";
			resets = "", "b";
			reset-names = "usb30_mstr_rst";
			qca,host = "";
			status = "ok";
			dwc3@8A00000 {
				compatible = "snps,dwc3";
				reg = <0x08a00000 0x0000e000>;
				interrupts = "�", "";
				usb-phy = "";
				snps,dis_ep_cache_eviction = [];
				tx-fifo-resize = [];
				snps,usb3-u1u2-disable = [];
				snps,nominal-elastic-buffer = [];
				snps,is-utmi-l1-suspend = [];
				snps,hird-threshold = "";
				snps,dis_u2_susphy_quirk = [];
				snps,dis_u3_susphy_quirk = [];
				snps,quirk-ref-clock-adjustment = "�Y";
				snps,quirk-ref-clock-period = "";
				snps,quirk-30m-sb-sel = "";
				dr_mode = "host";
			};
		};
		qcom,msm-imem@8600000 {
			compatible = "qcom,msm-imem";
			reg = <0x08600000 0x00001000>;
			ranges = <0x00000000 0x08600000 0x00001000>;
			#address-cells = "";
			#size-cells = "";
			restart-reason-buf-addr@7a4 {
				compatible = "qcom,msm-imem-restart-reason-buf-addr";
				reg = "�", "";
			};
		};
		qcom,msm-eud@58000 {
			compatible = "qcom,msm-eud";
			reg = <0x00058000 0x00001000 0x00059000 0x00002000 0x0005a000 0x00001000>;
			reg-names = "eud_base", "eud_mode_mgr", "eud_mode_mgr2";
			interrupts = "�", "";
			interrupt-names = "eud_irq";
			status = "ok";
		};
		interrupt-controller@b000000 {
			compatible = "qcom,msm-qgic2";
			interrupt-controller = [];
			#interrupt-cells = "";
			reg = <0x0b000000 0x00001000 0x0b002000 0x00001000 0x0b001000 0x00001000 0x0b004000 0x00001000>;
			interrupts = "", "	", "";
			ranges = "", "�", "�";
			phandle = "";
			v2m@0 {
				compatible = "arm,gic-v2m-frame";
				msi-controller = [];
				reg = "�";
				phandle = "";
			};
			v2m@1000 {
				compatible = "arm,gic-v2m-frame";
				msi-controller = [];
				reg = "", "�";
			};
		};
		watchdog@b017000 {
			compatible = "qcom,kpss-wdt";
			interrupts = "", "";
			reg = "p", "@";
			clocks = "";
		};
		mailbox@b111000 {
			compatible = "qcom,ipq5018-apcs-apps-global";
			reg = <0x0b111000 0x00006000>;
			#clock-cells = "";
			#mbox-cells = "";
			phandle = "";
		};
		timer {
			compatible = "arm,armv8-timer";
			interrupts = "", "", "", "", "", "", "", "", "", "", "", "";
		};
		timer@b120000 {
			#address-cells = "";
			#size-cells = "";
			ranges = [];
			compatible = "arm,armv7-timer-mem";
			reg = <0x0b120000 0x00001000>;
			clock-frequency = <0x0124f800>;
			frame@b120000 {
				frame-number = "";
				interrupts = "", "", "", "";
				reg = <0x0b121000 0x00001000 0x0b122000 0x00001000>;
			};
			frame@b123000 {
				frame-number = "";
				interrupts = "	", "";
				reg = <0x0b123000 0x00001000>;
				status = "disabled";
			};
			frame@b124000 {
				frame-number = "";
				interrupts = "
", "";
				reg = <0x0b124000 0x00001000>;
				status = "disabled";
			};
			frame@b125000 {
				frame-number = "";
				interrupts = "", "";
				reg = <0x0b125000 0x00001000>;
				status = "disabled";
			};
			frame@b126000 {
				frame-number = "";
				interrupts = "", "";
				reg = <0x0b126000 0x00001000>;
				status = "disabled";
			};
			frame@b127000 {
				frame-number = "";
				interrupts = "", "";
				reg = <0x0b127000 0x00001000>;
				status = "disabled";
			};
			frame@b128000 {
				frame-number = "";
				interrupts = "", "";
				reg = <0x0b128000 0x00001000>;
				status = "disabled";
			};
		};
		pci@80000000 {
			compatible = "qcom,pcie-ipq5018";
			reg = "�", "�", " ", "��", "", "", "�", "0", "�", "", "V", "";
			reg-names = "dbi", "elbi", "atu", "parf", "config", "system_noc";
			device_type = <0x70636900>;
			linux,pci-domain = "";
			bus-range = "�";
			num-lanes = "";
			#address-cells = "";
			#size-cells = "";
			axi-halt-val = "";
			phys = "";
			phy-names = "pciephy";
			ranges = <0x81000000 0x00000000 0x80200000 0x80200000 0x00000000 0x00100000 0x82000000 0x00000000 0x80300000 0x80300000 0x00000000 0x10000000>;
			#interrupt-cells = "";
			interrupt-map-mask = "";
			interrupt-map = "", "", "�", "", "", "", "�", "", "", "", "�", "", "", "", "�", "";
			interrupts = "w", "";
			interrupt-names = "global_irq";
			clocks = "", "x", "", "Q", "", "S", "", "O", "", "P", "", "R";
			clock-names = "iface", "axi_m", "axi_s", "ahb", "aux", "axi_bridge";
			resets = "", "1", "", "2", "", "3", "", "4", "", "5", "", "6", "", "7", "", "8";
			reset-names = "pipe", "sleep", "sticky", "axi_m", "axi_s", "ahb", "axi_m_sticky", "axi_s_sticky";
			msi-parent = "";
			status = "disabled";
			perst-gpio = "", "", "";
			pcie_x1_rp {
				reg = "";
				status = "disabled";
				qcom,mhi@0 {
					reg = "";
				};
			};
		};
		pci@a0000000 {
			compatible = "qcom,pcie-ipq5018";
			reg = "�", "�", " ", "��", "", "", "", "0", "�", "", "V", "";
			reg-names = "dbi", "elbi", "atu", "parf", "config", "system_noc";
			device_type = <0x70636900>;
			linux,pci-domain = "";
			bus-range = "�";
			num-lanes = "";
			#address-cells = "";
			#size-cells = "";
			axi-halt-val = "";
			phys = "";
			phy-names = "pciephy";
			ranges = <0x81000000 0x00000000 0xa0200000 0xa0200000 0x00000000 0x00100000 0x82000000 0x00000000 0xa0300000 0xa0300000 0x00000000 0x10000000>;
			#interrupt-cells = "";
			interrupt-map-mask = "";
			interrupt-map = "", "", "K", "", "", "", "N", "", "", "", "O", "", "", "", "S", "";
			interrupts = "3", "";
			interrupt-names = "global_irq";
			clocks = "", "w", "", "L", "", "N", "", "J", "", "K", "", "M";
			clock-names = "iface", "axi_m", "axi_s", "ahb", "aux", "axi_bridge";
			resets = "", "%", "", "&", "", "'", "", "(", "", ")", "", "*", "", "+", "", ",";
			reset-names = "pipe", "sleep", "sticky", "axi_m", "axi_s", "ahb", "axi_m_sticky", "axi_s_sticky";
			msi-parent = "";
			status = "disabled";
			perst-gpio = "", "", "";
			pcie_x2_rp {
				reg = "";
				status = "disabled";
				qcom,mhi@1 {
					reg = "";
				};
			};
		};
		remoteproc@cd00000 {
			compatible = "qcom,ipq5018-q6-mpd";
			reg = "�", "@@��", "��", "";
			reg-names = "qdsp6", "tcsr-msip", "tcsr-q6";
			interrupts-extended = "", "#", "", "", "", "", "", "", "", "";
			interrupt-names = "wdog", "fatal", "ready", "handover", "stop-ack";
			resets = "", "m", "", "l";
			reset-names = "wcss_aon_reset", "wcss_q6_reset";
			clocks = "", "W", "", "�", "", "U", "", "V", "", "X", "", "Y", "", "�";
			clock-names = "gcc_q6_axis_clk", "gcc_wcss_ecahb_clk", "gcc_q6_axim_clk", "gcc_q6_axim2_clk", "gcc_q6_ahb_clk", "gcc_q6_ahb_s_clk", "gcc_wcss_axi_s_clk";
			qcom,halt-regs = "", "�", "�";
			qcom,smem-states = " ", " ", "";
			qcom,smem-state-names = "shutdown", "stop";
			#address-cells = "";
			#size-cells = "";
			ranges = [];
			firmware = "IPQ5018/q6_fw.mdt";
			memory-region = "!", """;
			qcom,rproc = "#";
			qcom,bootargs_smem = "�";
			boot-args = "", "", "", "", "", "", "", "";
			status = "ok";
			phandle = "#";
			glink-edge {
				interrupts = "�", "";
				qcom,remote-pid = "";
				mboxes = "", "";
				global_timer = <0x004a5000>;
				qrtr_requests {
					qcom,glink-channels = "IPCRTR";
				};
			};
			remoteproc_pd1@4ab000 {
				compatible = "qcom,ipq5018-wcss-ahb-mpd";
				reg = "J�", " ";
				reg-names = <0x726d6200>;
				firmware = "IPQ5018/q6_fw.mdt";
				m3_firmware = "IPQ5018/m3_fw.mdt";
				interrupts-extended = "", "", "", "	", "", "", "", "";
				interrupt-names = "fatal", "ready", "spawn-ack", "stop-ack";
				resets = "", "m", "", "d", "", "";
				reset-names = "wcss_aon_reset", "wcss_reset", "ce_reset";
				clocks = "", "�", "", "�", "", "�";
				clock-names = "gcc_wcss_ahb_s_clk", "gcc_wcss_acmt_clk", "gcc_wcss_axi_m_clk";
				qcom,halt-regs = "", "�", "�";
				qcom,smem-states = " ", "", " ", "	", " ", "
";
				qcom,smem-state-names = "shutdown", "stop", "spawn";
				memory-region = "$", "%", """;
				phandle = ")";
			};
			remoteproc_pd2 {
				compatible = "qcom,ipq5018-wcss-pcie-mpd";
				firmware = "IPQ5018/q6_fw.mdt";
				m3_firmware = "qcn6122/m3_fw.mdt";
				interrupts-extended = "", "", "", "", "", "", "", "";
				interrupt-names = "fatal", "ready", "spawn-ack", "stop-ack";
				qcom,smem-states = " ", "", " ", "", " ", "";
				qcom,smem-state-names = "shutdown", "stop", "spawn";
				memory-region = "&", "'", "(";
				phandle = "*";
			};
		};
		wifi@c000000 {
			compatible = "qcom,cnss-qca5018", "qcom,ipq5018-wifi";
			reg = <0x0c000000 0x01000000>;
			qcom,tgt-mem-mode = "";
			qcom,rproc = ")";
			interrupts = " ", "", "!", "", """, "", "$", "", "%", "", "&", "", "'", "", "(", "", ")", "", "*", "", "+", "", ",", "", "-", "", ".", "", "/", "", "0", "", "1", "", "2", "", "3", "", "4", "", "5", "", "6", "", "7", "", "N", "", "9", "", ":", "", ";", "", "<", "", "=", "", ">", "", "?", "", "@", "", "A", "", "B", "", "C", "", "D", "", "E", "", "F", "", "G", "", "H", "", "I", "", "J", "", "K", "", "L", "", "M", "", "8", "", "O", "", "V", "", "P", "", "Q", "", "R", "", "S", "";
			interrupt-names = "misc-pulse1", "misc-latch", "sw-exception", "ce0", "ce1", "ce2", "ce3", "ce4", "ce5", "ce6", "ce7", "ce8", "ce9", "ce10", "ce11", "host2wbm-desc-feed", "host2reo-re-injection", "host2reo-command", "host2rxdma-monitor-ring3", "host2rxdma-monitor-ring2", "host2rxdma-monitor-ring1", "reo2ost-exception", "wbm2host-rx-release", "reo2host-status", "reo2host-destination-ring4", "reo2host-destination-ring3", "reo2host-destination-ring2", "reo2host-destination-ring1", "rxdma2host-monitor-destination-mac3", "rxdma2host-monitor-destination-mac2", "rxdma2host-monitor-destination-mac1", "ppdu-end-interrupts-mac3", "ppdu-end-interrupts-mac2", "ppdu-end-interrupts-mac1", "rxdma2host-monitor-status-ring-mac3", "rxdma2host-monitor-status-ring-mac2", "rxdma2host-monitor-status-ring-mac1", "host2rxdma-host-buf-ring-mac3", "host2rxdma-host-buf-ring-mac2", "host2rxdma-host-buf-ring-mac1", "rxdma2host-destination-ring-mac3", "rxdma2host-destination-ring-mac2", "rxdma2host-destination-ring-mac1", "host2tcl-input-ring4", "host2tcl-input-ring3", "host2tcl-input-ring2", "host2tcl-input-ring1", "wbm2host-tx-completions-ring4", "wbm2host-tx-completions-ring3", "wbm2host-tx-completions-ring2", "wbm2host-tx-completions-ring1", "tcl2host-status-ring";
			status = "ok";
			qcom,multipd_arch = [];
			qcom,board_id = "";
			qcom,bdf-addr = <0x00000000 0x00000000 0x4c400000 0x00000000 0x00000000 0x00000000>;
			qcom,caldb-addr = "";
			qcom,caldb-size = "";
			qcom,userpd-subsys-name = "q6v5_wcss_userpd1";
			mem-region = "$";
		};
		wifi1@c000000 {
			compatible = "qcom,cnss-qcn6122", "qcom,cnss-qcn9100";
			msi-parent = "";
			interrupts = "�", "";
			status = "ok";
			qcom,multipd_arch = [];
			qcom,board_id = "`";
			qcom,tgt-mem-mode = "";
			qcom,bdf-addr = <0x00000000 0x00000000 0x4d300000 0x00000000 0x00000000 0x00000000>;
			qcom,caldb-addr = "";
			qcom,caldb-size = "";
			qcom,userpd-subsys-name = "q6v5_wcss_userpd2";
			qcom,rproc = "*";
			mem-region = "&";
		};
		wifi2@c000000 {
			compatible = "qcom,cnss-qcn6122";
			msi-parent = "";
			interrupts = "�", "";
			status = "disabled";
			qcom,rproc = "#";
		};
		wifi3@f00000 {
			compatible = "qcom,cnss-qcn9000";
			qcom,wlan-ramdump-dynamic = <0x00400000>;
			qrtr_node_id = " ";
			qca,auto-restart = [];
			status = "disabled";
		};
		wifi4@f00000 {
			compatible = "qcom,cnss-qcn9000";
			qcom,wlan-ramdump-dynamic = <0x00400000>;
			qrtr_node_id = "!";
			qca,auto-restart = [];
			status = "disabled";
		};
		wifi5@f00000 {
			compatible = "qcom,cnss-qcn9224";
			qcom,wlan-ramdump-dynamic = <0x00600000>;
			qca,auto-restart = [];
			status = "disabled";
		};
		wcss-smp2p {
			compatible = "qcom,smp2p";
			qcom,smem = "�", "�";
			interrupt-parent = "";
			interrupts = "�", "";
			mboxes = "", "	";
			qcom,local-pid = "";
			qcom,remote-pid = "";
			global_timer = <0x004a5000>;
			master-kernel {
				qcom,entry-name = "master-kernel";
				qcom,smp2p-feature-ssr-ack = [];
				#qcom,smem-state-cells = "";
				phandle = " ";
			};
			slave-kernel {
				qcom,entry-name = "slave-kernel";
				interrupt-controller = [];
				#interrupt-cells = "";
				phandle = "";
			};
		};
		nss-common {
			compatible = "qcom,nss-common";
			reg = "��", "";
			reg-names = "nss-misc-reset";
		};
		nss@40000000 {
			compatible = "qcom,nss";
			interrupts = "�", "", "�", "", "�", "", "�", "", "�", "", "�", "", "�", "", "�", "";
			reg = <0x07a00000 0x00000100 0x0b111000 0x00001000>;
			reg-names = "nphys", "qgic-phys";
			clocks = "", "�", "", "�", "", "�", "", "�", "", "�", "", "v", "", "�";
			clock-names = "nss-cfg-clk", "nss-dbg-clk", "nss-core-clk", "nss-utcm-clk", "nss-axi-clk", "nss-snoc-axi-clk", "nss-nc-axi-clk";
			qcom,id = "";
			qcom,num-queue = "";
			qcom,num-irq = "";
			qcom,num-pri = "";
			qcom,load-addr = <0x40000000>;
			qcom,low-frequency = [32a9f880];
			qcom,mid-frequency = [32a9f880];
			qcom,max-frequency = <0x3b9aca00>;
			qcom,ipv4-enabled = [];
			qcom,ipv4-reasm-enabled = [];
			qcom,ipv6-enabled = [];
			qcom,ipv6-reasm-enabled = [];
			qcom,tun6rd-enabled = [];
			qcom,l2tpv2-enabled = [];
			qcom,gre-enabled = [];
			qcom,map-t-enabled = [];
			qcom,pppoe-enabled = [];
			qcom,pptp-enabled = [];
			qcom,tunipip6-enabled = [];
			qcom,shaping-enabled = [];
			qcom,clmap-enabled = [];
			qcom,vxlan-enabled = [];
			qcom,match-enabled = [];
			qcom,mirror-enabled = [];
			qcom,crypto-enabled = [];
			qcom,ipsec-enabled = [];
			qcom,wlanredirect-enabled = [];
			qcom,gre-redir-enabled = [];
			qcom,gre-redir-mark-enabled = [];
			qcom,portid-enabled = [];
			qcom,wlan-dataplane-offload-enabled = [];
			qcom,pvxlan-enabled = [];
			qcom,udp-st-enabled = [];
		};
		syscon@b111000 {
			compatible = "syscon";
			reg = <0x0b111000 0x00001000>;
			phandle = "+";
		};
		bt@7000000 {
			compatible = "qcom,bt";
			firmware = "IPQ5018/bt_fw_patch.mdt";
			reg = "�0", "";
			reg-names = "bt_warm_rst";
			qcom,ipc = "+", "", "";
			interrupts = "�", "";
			resets = "", "";
			reset-names = "btss_reset";
			clocks = "", "$";
			clock-names = "lpo_clk";
			memory-region = ",";
			status = "ok";
			bt_maple {
				compatible = "qcom,maple-bt";
				status = "disabled";
			};
		};
		qcom,apss_clk@b111000 {
			compatible = "qcom,apss-ipq5018";
			reg = <0x0b111000 0x00006000>;
			#clock-cells = "";
			#reset-cells = "";
		};
		clock-controller@b188000 {
			compatible = "qcom,arm-cortex-acc";
			reg = <0x0b188000 0x00001000>;
			phandle = "";
		};
		clock-controller@b198000 {
			compatible = "qcom,arm-cortex-acc";
			reg = <0x0b198000 0x00001000>;
			phandle = "";
		};
		lpass@0xA000000 {
			compatible = "qca,lpass-ipq5018";
			reg = "
", ";��";
			clocks = "", "r", "", "s", "", "E", "", "F";
			clock-names = "snoc_axim", "snoc_sway", "axim", "sway";
			resets = "", "";
			reset-names = "lpass";
			status = "disabled";
		};
		pcm@0xA3C0000 {
			compatible = "qca,ipq5018-lpass-pcm";
			reg = "
<", "0";
			interrupts = "", "";
			interrupt-names = "out0";
			capture_memory = <0x6c706d00>;
			playback_memory = <0x6c706d00>;
			voice_loopback = "";
			status = "disabled";
		};
		pcm_lb@0 {
			compatible = "qca,ipq5018-pcm-lb";
			status = "disabled";
		};
		pwm@0x1941010 {
			compatible = "qti,ipq5018-pwm";
			reg = "�", " ";
			clocks = "", "�";
			clock-names = "core";
			src-freq = <0x05f5e100>;
			pwm-base-index = "";
			used-pwm-indices = "", "", "", "";
			status = "disabled";
		};
		tmc@6048000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�a";
			reg = <0x06048000 0x00001000 0x06064000 0x00015000>;
			reg-names = "tmc-base", "bam-base";
			memory-region = """;
			interrupts = "�", "";
			interrupt-names = "byte-cntr-irq";
			arm,buffer-size = <0x00100000>;
			arm,scatter-gather = [];
			coresight-ctis = "-", ".";
			coresight-name = "coresight-tmc-etr";
			coresight-csr = "/";
			funnel-address = <0x06041000 0x00001000>;
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			port {
				endpoint {
					slave-mode = [];
					remote-endpoint = "0";
					phandle = "1";
				};
			};
		};
		replicator@6046000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�	";
			reg = <0x06046000 0x00001000>;
			reg-names = "replicator-base";
			coresight-name = "coresight-replicator";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "1";
						phandle = "0";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "2";
						phandle = "3";
					};
				};
			};
		};
		tmc@6047000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�a";
			reg = <0x06047000 0x00001000>;
			reg-names = "tmc-base";
			coresight-ctis = "-", ".";
			coresight-name = "coresight-tmc-etf";
			arm,default-sink = [];
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "3";
						phandle = "2";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "4";
						phandle = "5";
					};
				};
			};
		};
		funnel@6041000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�";
			reg = <0x06041000 0x00001000>;
			reg-names = "funnel-base";
			coresight-name = "coresight-funnel-in0";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "5";
						phandle = "4";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "6";
						phandle = "<";
					};
				};
				port@2 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "7";
						phandle = ">";
					};
				};
				port@3 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "8";
						phandle = "@";
					};
				};
				port@4 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "9";
						phandle = "K";
					};
				};
				port@5 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = ":";
						phandle = "I";
					};
				};
				port@6 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = ";";
						phandle = "H";
					};
				};
			};
		};
		funnel@6100000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�";
			reg = <0x06100000 0x00001000>;
			reg-names = "funnel-base";
			coresight-name = "coresight-funnel-center";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "<";
						phandle = "6";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "=";
						phandle = "J";
					};
				};
			};
		};
		funnel@6120000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�";
			reg = <0x06120000 0x00001000>;
			reg-names = "funnel-base";
			coresight-name = "coresight-funnel-right";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = ">";
						phandle = "7";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "?";
						phandle = "A";
					};
				};
			};
		};
		funnel@6130000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�";
			reg = <0x06130000 0x00001000>;
			reg-names = "funnel-base";
			coresight-name = "coresight-funnel-mm";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "@";
						phandle = "8";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
					};
				};
			};
		};
		funnel@61a1000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�";
			reg = <0x061a1000 0x00001000>;
			reg-names = "funnel-base";
			coresight-name = "coresight-funnel-apss0";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "A";
						phandle = "?";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "B";
						phandle = "E";
					};
				};
				port@2 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "C";
						phandle = "G";
					};
				};
			};
		};
		etm@619c000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�]";
			reg = <0x0619c000 0x00001000>;
			coresight-name = "coresight-etm0";
			cpu = "D";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			port {
				endpoint {
					remote-endpoint = "E";
					phandle = "B";
				};
			};
		};
		etm@619d000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�]";
			reg = <0x0619d000 0x00001000>;
			coresight-name = "coresight-etm1";
			cpu = "F";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			port {
				endpoint {
					remote-endpoint = "G";
					phandle = "C";
				};
			};
		};
		rpm_etm0 {
			compatible = "qcom,coresight-remote-etm";
			coresight-name = "coresight-rpm-etm0";
			qcom,inst-id = "";
			port {
				endpoint {
					remote-endpoint = "H";
					phandle = ";";
				};
			};
		};
		stm@6002000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�b";
			reg = <0x06002000 0x00001000 0x09280000 0x00180000>;
			reg-names = "stm-base", "stm-stimulus-base";
			coresight-name = "coresight-stm";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			port {
				endpoint {
					remote-endpoint = "I";
					phandle = ":";
				};
			};
		};
		cti@6010000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06010000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti0";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			phandle = "-";
		};
		cti@6011000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06011000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti1";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6012000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06012000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti2";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6013000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06013000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti3";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6014000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06014000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti4";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6015000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06015000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti5";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6016000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06016000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti6";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6017000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06017000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti7";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6018000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06018000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti8";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			phandle = ".";
		};
		cti@6019000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06019000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti9";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@601a000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0601a000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti10";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@601b000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0601b000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti11";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@601c000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0601c000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti12";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@601d000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0601d000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti13";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@601e000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0601e000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti14";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@601f000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0601f000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti15";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6198000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06198000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti-cpu0";
			cpu = "D";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@6199000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x06199000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti-cpu1";
			cpu = "F";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		cti@610c000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�f";
			reg = <0x0610c000 0x00001000>;
			reg-names = "cti-base";
			coresight-name = "coresight-cti-rpm-cpu0";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		csr@6001000 {
			compatible = "qcom,coresight-csr";
			reg = <0x06001000 0x00001000>;
			reg-names = "csr-base";
			coresight-name = "coresight-csr";
			qcom,blk-size = "";
			qcom,set-byte-cntr-support = [];
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			phandle = "/";
		};
		dbgui@6108000 {
			compatible = "qcom,coresight-dbgui";
			reg = <0x06108000 0x00001000>;
			reg-names = "dbgui-base";
			coresight-name = "coresight-dbgui";
			qcom,dbgui-addr-offset = "0";
			qcom,dbgui-data-offset = "0";
			qcom,dbgui-size = "@";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			port {
				endpoint {
					remote-endpoint = "J";
					phandle = "=";
				};
			};
		};
		tpda@6004000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�i";
			reg = <0x06004000 0x00001000>;
			reg-names = "tpda-base";
			coresight-name = "coresight-tpda";
			qcom,tpda-atid = "@";
			qcom,cmb-elem-size = " ";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			ports {
				#address-cells = "";
				#size-cells = "";
				port@0 {
					reg = "";
					endpoint {
						remote-endpoint = "K";
						phandle = "9";
					};
				};
				port@1 {
					reg = "";
					endpoint {
						slave-mode = [];
						remote-endpoint = "L";
						phandle = "M";
					};
				};
			};
		};
		tpdm@6110000 {
			compatible = "arm,primecell";
			arm,primecell-periphid = "�h";
			reg = <0x06110000 0x00001000>;
			reg-names = "tpdm-base";
			coresight-name = "coresight-tpdm-dcc";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
			port {
				endpoint {
					remote-endpoint = "M";
					phandle = "L";
				};
			};
		};
		hwevent@6101000 {
			compatible = "qcom,coresight-hwevent";
			reg = "", "H�", "", "H�", "", "H�", "�", "", "H�", "", "H";
			reg-names = "center-wrapper-mux", "center-wrapper-lockaccess", "right-wrapper-mux", "right-wrapper-lockaccess", "mm-wrapper-mux", "mm-wrapper-lockaccess", "mm-fun-lockaccess", "mm-fun", "in-fun-lockaccess", "in-fun";
			coresight-name = "coresight-hwevent";
			clocks = "", "a", "", "^";
			clock-names = "apb_pclk", "core_a_clk";
		};
		qfprom_nvmem@a0000 {
			#address-cells = "";
			#size-cells = "";
			compatible = "qcom,qfprom";
			reg = <0x000a0000 0x00001000>;
			calib@248 {
				reg = "H", "";
				phandle = "N";
			};
		};
		thermal-sensor@4a9000 {
			compatible = "qcom,ipq5018-tsens";
			reg = <0x004a9000 0x00001000 0x004a8000 0x00001000>;
			nvmem-cells = "N";
			nvmem-cell-names = "calib";
			interrupts = "�", "";
			#qcom,sensors = "";
			#thermal-sensor-cells = "";
			phandle = "Q";
		};
		dp1 {
			device_type = "network";
			compatible = "qcom,nss-dp";
			clocks = "", "o";
			clock-names = "nss-snoc-gmac-axi-clk";
			qcom,id = "";
			reg = <0x39c00000 0x00010000>;
			interrupts = "e", "";
			qcom,mactype = "";
			qcom,link-poll = "";
			qcom,phy-mdio-addr = "";
			mdio-bus = "";
			local-mac-address = [5899a813181b];
			phy-mode = "sgmii";
		};
		dp2 {
			device_type = "network";
			compatible = "qcom,nss-dp";
			clocks = "", "q";
			clock-names = "nss-snoc-gmac-axi-clk";
			qcom,id = "";
			reg = <0x39d00000 0x00010000>;
			interrupts = "m", "";
			qcom,mactype = "";
			local-mac-address = [5895d813282a];
			phy-mode = "sgmii";
		};
		gpio_keys {
			compatible = "gpio-keys";
			pinctrl-0 = "O";
			pinctrl-names = "default";
			button@1 {
				label = <0x77707300>;
				linux,code = "";
				gpios = "", """, "";
				linux,input-type = "";
				debounce-interval = "<";
			};
		};
		leds {
			compatible = "gpio-leds";
			pinctrl-0 = "P";
			pinctrl-names = "default";
			led@35 {
				label = "mesh";
				gpios = "", "!", "";
				linux,default-trigger = "mesh";
				default-state = <0x6f666600>;
			};
			led@30 {
				label = <0x70777200>;
				gpios = "", "", "";
				linux,default-trigger = <0x70777200>;
				default-state = "on";
			};
		};
	};
	qti,scm_restart_reason {
		compatible = "qti_ipq5018,scm_restart_reason";
		dload_status = "";
		dload_warm_reset = "";
	};
	qcom,test@0 {
		compatible = "qcom,testmhi";
		qcom,wlan-ramdump-dynamic = <0x00400000>;
		status = "ok";
	};
	ctx-save {
		compatible = "qti,ctxt-save-ipq5018";
	};
	qti,sps {
		compatible = "qti,msm-sps-4k";
		qti,pipe-attr-ee = [];
	};
	thermal-zones {
		status = "ok";
		tsens_tz_sensor1 {
			polling-delay-passive = "";
			polling-delay = "";
			thermal-sensors = "Q", "";
			trips {
				cpu-critical-hi {
					temperature = "��";
					hysteresis = "";
					type = "critical_high";
				};
				cpu-config-hi {
					temperature = "��";
					hysteresis = "";
					type = "configurable_hi";
				};
				cpu-config-lo {
					temperature = "_�";
					hysteresis = "";
					type = "configurable_lo";
				};
				cpu-critical-low {
					temperature = "";
					hysteresis = "";
					type = "critical_low";
				};
			};
		};
		tsens_tz_sensor2 {
			polling-delay-passive = "";
			polling-delay = "";
			thermal-sensors = "Q", "";
			trips {
				cpu-critical-hi {
					temperature = "��";
					hysteresis = "";
					type = "critical_high";
				};
				cpu-config-hi {
					temperature = "��";
					hysteresis = "";
					type = "configurable_hi";
				};
				cpu-config-lo {
					temperature = "_�";
					hysteresis = "";
					type = "configurable_lo";
				};
				cpu-critical-low {
					temperature = "";
					hysteresis = "";
					type = "critical_low";
				};
			};
		};
		tsens_tz_sensor3 {
			polling-delay-passive = "";
			polling-delay = "";
			thermal-sensors = "Q", "";
			trips {
				cpu-critical-hi {
					temperature = "��";
					hysteresis = "";
					type = "critical_high";
				};
				cpu-config-hi {
					temperature = "��";
					hysteresis = "";
					type = "configurable_hi";
				};
				cpu-config-lo {
					temperature = "_�";
					hysteresis = "";
					type = "configurable_lo";
				};
				cpu-critical-low {
					temperature = "";
					hysteresis = "";
					type = "critical_low";
				};
			};
		};
		tsens_tz_sensor4 {
			polling-delay-passive = "";
			polling-delay = "";
			thermal-sensors = "Q", "";
			trips {
				cpu-critical-hi {
					temperature = "��";
					hysteresis = "";
					type = "critical_high";
				};
				cpu-config-hi {
					temperature = "��";
					hysteresis = "";
					type = "configurable_hi";
				};
				cpu-config-lo {
					temperature = "_�";
					hysteresis = "";
					type = "configurable_lo";
				};
				cpu-critical-low {
					temperature = "";
					hysteresis = "";
					type = "critical_low";
				};
			};
		};
	};
	aliases {
		sdhc1 = "/soc/sdhci@7804000";
		serial0 = "/soc/serial@78af000";
		serial1 = "/soc/serial@78b0000";
		ethernet0 = "/soc/dp1";
		ethernet1 = "/soc/dp2";
	};
	chosen {
		bootargs = "console=ttyMSM0,115200n8 ubi.mtd=rootfs root=mtd:ubi_rootfs rootfstype=squashfs rootwait";
		bootargs-append = " ubi.mtd=rootfs root=/dev/ubiblock0_1 swiotlb=1 coherent_pool=2M";
	};
};